* /usr/local/bin/xorn netlist --symbol-library /usr/local/share/gEDA/sym/misc --symbol-library /usr/local/share/gEDA/sym/power --symbol-library /usr/local/share/gEDA/sym/relay --symbol-library /usr/local/share/gEDA/sym/opto --symbol-library /usr/local/share/gEDA/sym/supervisor --symbol-library /usr/local/share/gEDA/sym/pla --symbol-library /usr/local/share/gEDA/sym/rf --symbol-library /usr/local/share/gEDA/sym/tube --symbol-library /usr/local/share/gEDA/sym/transistor --symbol-library /usr/local/share/gEDA/sym/micro --symbol-library /usr/local/share/gEDA/sym/memory --symbol-library /usr/local/share/gEDA/sym/bus --symbol-library /usr/local/share/gEDA/sym/xilinx --symbol-library /usr/local/share/gEDA/sym/st --symbol-library /usr/local/share/gEDA/sym/philips --symbol-library /usr/local/share/gEDA/sym/national --symbol-library /usr/local/share/gEDA/sym/minicircuits --symbol-library /usr/local/share/gEDA/sym/maxim --symbol-library /usr/local/share/gEDA/sym/linear --symbol-library /usr/local/share/gEDA/sym/lattice --symbol-library /usr/local/share/gEDA/sym/irf --symbol-library /usr/local/share/gEDA/sym/idt --symbol-library /usr/local/share/gEDA/sym/dec --symbol-library /usr/local/share/gEDA/sym/apex --symbol-library /usr/local/share/gEDA/sym/amphenol --symbol-library /usr/local/share/gEDA/sym/altera --symbol-library /usr/local/share/gEDA/sym/allegro --symbol-library /usr/local/share/gEDA/sym/asicpads --symbol-library /usr/local/share/gEDA/sym/asic --symbol-library /usr/local/share/gEDA/sym/switcap --symbol-library /usr/local/share/gEDA/sym/spice --symbol-library /usr/local/share/gEDA/sym/cascade --symbol-library /usr/local/share/gEDA/sym/ecl --symbol-library /usr/local/share/gEDA/sym/4000 --symbol-library /usr/local/share/gEDA/sym/74 --symbol-library /usr/local/share/gEDA/sym/IEC417 --symbol-library /usr/local/share/gEDA/sym/titleblock --symbol-library /usr/local/share/gEDA/sym/switch --symbol-library /usr/local/share/gEDA/sym/radio --symbol-library /usr/local/share/gEDA/sym/io --symbol-library /usr/local/share/gEDA/sym/net-power --symbol-library /usr/local/share/gEDA/sym/diode --symbol-library /usr/local/share/gEDA/sym/connector --symbol-library /usr/local/share/gEDA/sym/analog --symbol-library /usr/local/share/gEDA/sym/local -g guile -O add-to-load-path=/usr/local/share/gEDA/scheme -O load=/usr/local/share/gEDA/scheme/gnetlist.scm -O load=/usr/local/share/gEDA/scheme/gnet-spice-sdb.scm -O load=/usr/local/share/gEDA/scheme/gnetlist-post.scm -O guile-proc=spice-sdb -O use-spice-netnames -v -o km312_feedback.cir km312_feedback.sch km312_feedback_test.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*vvvvvvvv  Included SPICE model from AMP_OP.cir vvvvvvvv
*******************************
* Begin .SUBCKT model         *
* spice-sdb ver 4.28.2007     *
*******************************
.SUBCKT AMP_OP 3 2 1
*==============  Begin SPICE netlist of main design ============
.MODEL D1N4148 D (IS=4.352E-9 N=1.906 BV=110 IBV=0.0001 RS=0.6458 CJO=7.048E-13 VJ=0.869 M=0.03 FC=0.5 TT=3.48E-9 )
R3 10 5 5K
V2 11 0 DC 4V
* begin vcvs expansion, e<name>
E4 12 0 11 0 -1
Isense_E4 11 0 dc 0
IOut_E4 12 0 dc 0
* end vcvs expansion
D3 12 5 D1N4148
D4 5 11 D1N4148
C1 0 7 2nF
V1 9 0 DC 0.4V
D1 8 6 D1N4148
D2 6 9 D1N4148
* begin vcvs expansion, e<name>
E3 10 0 7 0 1000
Isense_E3 7 0 dc 0
IOut_E3 10 0 dc 0
* end vcvs expansion
* begin vcvs expansion, e<name>
E2 8 0 9 0 -1
Isense_E2 9 0 dc 0
IOut_E2 8 0 dc 0
* end vcvs expansion
R2 6 7 1meg
R1 4 6 5K
* begin vcvs expansion, e<name>
E5 1 0 5 0 1
Isense_E5 5 0 dc 0
IOut_E5 1 0 dc 0
* end vcvs expansion
* begin vcvs expansion, e<name>
E1 4 0 2 3 100
Isense_E1 2 3 dc 0
IOut_E1 4 0 dc 0
* end vcvs expansion
.ends AMP_OP
*******************************
*^^^^^^^^  End of included SPICE model from AMP_OP.cir ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
.MODEL D1N4148 D (IS=4.352E-9 N=1.906 BV=110 IBV=0.0001 RS=0.6458 CJO=7.048E-13 VJ=0.869 M=0.03 FC=0.5 TT=3.48E-9 )
.MODEL DBAT85 D (IS = 2.076E-7 N = 1.023 BV = 33 IBV = 10E-6 RS = 2.326 CJO = 1.21E-11 VJ = 0.1319 M = 0.2904 EG = 0.69 XTI = 2 )
.OPTIONS *DC V200 0 12 0.2 V201 0 6 0.1
V201 I_REQ 0 DC 0 AC 0
V200 MEASURE_1 MEASURE_2 DC 0 AC 0
X208 12 0 FEDDBACK_FULL AMP_OP
R234 11 12 750K
R233 12 FEDDBACK_FULL 750K
D213 12 11 DBAT85
X207 10 0 11 AMP_OP
R232 10 11 100K
R231 8 10 100K
R230 6 10 100K
D212 9 8 DBAT85
X206 9 0 8 AMP_OP
R228 I_REQ 9 750K
R229 9 8 750K
D211 6 7 DBAT85
R227 6 feedback 0.1m
X204 7 0 6 AMP_OP
R224 3 7 100K
R225 7 6 750K
X203 4 5 3 AMP_OP
R220 1 4 750K
R223 0 5 100K
R222 2 5 750K
R221 4 3 100K
C201 1 2 1uF
R226 2 1 750K
D209 2 MEASURE_1 D1N4148
D210 2 MEASURE_2 D1N4148
D208 MEASURE_2 1 D1N4148
D207 MEASURE_1 1 D1N4148
.end
